require recipes-core/images/core-image-minimal.bb

SUMMARY = "sample rust-7seg layer"
IMAGE_INSTALL += "rust-7seg"