require recipes-core/images/custom-image.bb

SUMMARY = "sample rust-7seg layer"
IMAGE_INSTALL += "rust-7seg"